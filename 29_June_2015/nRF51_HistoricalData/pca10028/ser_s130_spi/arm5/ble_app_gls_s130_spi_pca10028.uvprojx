# Keil uVision project ble_app_gls_s130_spi_pca10028.uvprojx, settings and files
target nrf51422_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: SPI_MASTER_0_ENABLE BLE_STACK_SUPPORT_REQD SWI_DISABLE3 SVCALL_AS_NORMAL_FUNCTION S130 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SWI_DISABLE0
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1, nRF_Serialization:Internal:serapp_codecs_s130_ble_gap_evt 2.0.0, nRF_Serialization:Internal:serapp_codecs_s130_nrf_soc 2.0.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Serialization:Internal:serapp_mw_s130 2.0.0, nRF_Libraries:app_error 3.0.0, nRF_Serialization:Internal:serapp_hal_power_system_off 2.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_gap 2.0.0, nRF_Libraries:app_button 3.0.0, nRF_SoftDevice:s130 1.0.0, nRF_Drivers:spi_master 3.0.0, nRF_Serialization:Internal:serapp_s130 2.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_evt_mux 2.0.0, nRF_Drivers:nrf_gpiote 3.0.0, nRF_Serialization:Internal:ser_softdevice_handler 2.0.0, nRF_Libraries:app_util 3.0.0, nRF_Libraries:app_scheduler 3.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_gattc 2.0.0, nRF_Drivers:nrf_error 3.0.0, nRF_BLE:BLE_Modules:ble_conn_params 3.0.0, nRF_BLE:BLE_Modules:ble_service_common 3.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_gatts_evt 2.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_l2cap 2.0.0, Board Support:bsp_btn_ble 8.1.1, nRF_Serialization:Internal:serapp_codecs_s130_ble_l2cap_evt 2.0.0, nRF_Serialization:ser_phy 2.0.0, nRF_Serialization:Internal:ser_app_hal 2.0.0, nRF_BLE:BLE_Services:ble_bas 3.0.0, nRF_Serialization:Internal:ser_hal_transport 2.0.0, nRF_Libraries:retarget 3.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_gatts 2.0.0, Board Support:bsp 8.1.1, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_Libraries:app_fifo 3.0.0, nRF_BLE:BLE_Modules:ble_racp 3.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_Drivers:pstorage 3.0.0, nRF_Serialization:Internal:ser_sd_transport 2.0.0, nRF_Serialization:Internal:ser_codecs_common 2.0.0, nRF_BLE:BLE_Modules:device_manager 3.0.0, nRF_BLE:BLE_Services:ble_dis 3.0.0, nRF_Libraries:sensorsim 3.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble 2.0.0, nRF_Serialization:Internal:ser_codecs_s130_ble_struct 2.0.0, nRF_Serialization:Internal:serapp_codecs_s130_ble_gattc_evt 2.0.0, nRF_Libraries:app_trace 3.0.0, nRF_Serialization:Internal:ser_codecs_s130_ble_gattc_struct 2.0.0, nRF_BLE:BLE_Modules:ble_advertising 3.0.0, nRF_Serialization:Internal:cond_field_serialization 2.0.0, nRF_Drivers:nrf_soc 3.0.0, nRF_Drivers:nrf_drv_gpiote 3.0.0, nRF_Drivers:nrf_drv_common 3.0.0, nRF_Drivers:ble_flash 3.0.0, nRF_BLE:BLE_Services:ble_gls 3.0.0, nRF_Libraries:app_timer 3.0.0, nRF_Serialization:Internal:app_mailbox 2.0.0, nRF_Drivers:app_uart 3.0.0, nRF_BLE:BLE_Modules:ble_advdata 3.0.0, nRF_Serialization:Internal:ser_codecs_s130_ble_gatts_struct 2.0.0, nRF_BLE:BLE_Modules:ble_common 3.0.0, nRF_Serialization:Internal:ser_codecs_s130_ble_gap_struct 2.0.0
